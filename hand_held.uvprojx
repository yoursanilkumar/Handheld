# Keil uVision project hand_held.uvprojx, settings and files
target hello (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PGE Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Hand_Held +hex
  AfterMake: fromelf --bin --output .\rvmdk\Hand_Held.bin .\rvmdk\Hand_Held.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..;..\..\..\..;.\libraries\inc;.\libraries\inc;.\libraries\driverlib\rvmdk;.\libraries\utils;.\inc;.\driverlib\rvmdk;.\libraries\driverlib\rvmdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: hello.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S serial.h main.h RS232.c NHD15128128G.c main.c Keypad.c uartstdio.c
  group Libraries
    ./libraries/driverlib/rvmdk/: driverlib.lib
    ./grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.2.0
